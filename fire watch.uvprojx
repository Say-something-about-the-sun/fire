# Keil uVision project fire watch.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) XRAM(0x6C000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: fire watch +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=177 --cpu Cortex-M4.fp
  c include: .\CMSIS;.\Hardware;.\Library\inc;.\Library\src;.\Start;.\System;.\User;.\System\delay;.\System\sys;.\System\usart;.\System\usart2;.\System\usart3;.\FatFS;.\FatFS\option;.\Cjson;.\TJpgDec;.\FreeRTOS\ARM_CM4F;.\FreeRTOS\include;.\FreeRTOS\src;.\ov5640;.\SDcard;.\ESP8266;.\water_pump;.\dht11;.\key
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x6c000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Start
    ./Start/: stm32f4xx_it.c system_stm32f4xx.c startup_stm32f40_41xxx.s stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.h system_stm32f4xx.h
  group Library
    ./Library/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_cec.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dfsdm.h stm32f4xx_dma.h stm32f4xx_dma2d.h stm32f4xx_dsi.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_flash_ramfunc.h stm32f4xx_fmpi2c.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_lptim.h stm32f4xx_ltdc.h stm32f4xx_pwr.h stm32f4xx_qspi.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sai.h stm32f4xx_sdio.h stm32f4xx_spdifrx.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
    ./Library/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CMSIS
    ./CMSIS/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group System
    ./System/delay/: delay.c delay.h
    ./System/sys/: sys.c sys.h
    ./System/usart/: usart.c usart.h
    ./System/usart2/: usart2.c usart2.h
    ./System/usart3/: usart3.c usart3.h
  group Hardware
    ./Hardware/: smoke.c smoke.h RTC.c RTC.h extsram.c extsram.h jpeg_decoder.c jpeg_decoder.h jpeg_serial.c jpeg_serial.h image_preprocess.c image_preprocess.h fire_detection.c fire_detection.h led.c led.h
  group FatFS
    ./FatFS/: diskio.c diskio.h ff.c ff.h ffconf.h integer.h
    ./FatFS/option/: cc936.c syscall.c
  group Cjson
    ./Cjson/: cJSON.c cJSON.h
  group TJpgDec
    ./TJpgDec/: tjpgd.c tjpgd.h tjpgdcnf.h
  group User
    ./User/: main.c
  group FreeRTOS
    ./FreeRTOS/src/: croutine.c event_groups.c heap_4.c list.c queue.c tasks.c timers.c
    ./FreeRTOS/ARM_CM4F/: port.c
    ./FreeRTOS/include/: FreeRTOSConfig.h
  group SDcard
    ./SDcard/: sd_data_manager.c sd_data_manager.h SDCard.c SDCard.h sdcard_jpeg.c sdcard_jpeg.h sdio_sdcard.c sdio_sdcard.h
  group esp8266
    ./ESP8266/: ESP8266.c ESP8266.h esp8266_report.c esp8266_report.h
  group ov5640
    ./ov5640/: dcmi.c dcmi.h ov5640.c ov5640.h ov5640cfg.h sccb.c sccb.h
  group water_pump
    ./water_pump/: water_pump.c
  group dht11
    ./dht11/: dht11.c
  group key
    ./key/: key.c
